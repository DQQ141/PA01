# Keil uVision project project.uvprojx, settings and files
target project (6220000::V6.22::ARMCLANG)
  device: STM32H750ZBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: project
  AfterMake: C:\Users\xieyushen\Desktop\code\PA01\tools\bin\bin.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,DATA_IN_D2_SRAM
  c misc: -Wno-unknown-warning-option -Wno-gnu-designator  -Wno-unicode-homoglyph
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../../bsp;../../bsp/lvgl;../../app/factory/ui/lvgl/custom;../../app/factory/ui/lvgl/generated;../../app/factory/ui/lvgl/lvgl;../../app/factory/ui/lvgl/lvgl/src;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc
  memory RVCT1: ROM 0x90000000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT9: RAM 0x20004000 size 0x1c000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\release.sct
  group app
    ../../app/: app.c
    ../../app/test/: test_app.c
    ../../app/os_monitor/: os_monitor_app.c
    ../../app/factory/: factory_app.c
    ../../app/factory/button/: factory_button.c
    ../../app/factory/power/: factory_power.c
    ../../app/factory/ui/: factory_ui.c
    ../../app/script/: script_app.c
    ../../app/factory/rf/: factory_rf.c
  group bsp
    ../../bsp/: bsp.c
    ../../bsp/os/: os_bsp.c
    ../../bsp/time/: time_bsp.c
    ../../bsp/log/: log_bsp.c
    ../../bsp/gpio/: gpio_bsp.c
    ../../bsp/roller/: roller_bsp.c
    ../../bsp/serial_led/: serial_led_bsp.c
    ../../bsp/player/: player_bsp.c
    ../../bsp/adc/: adc_bsp.c
    ../../bsp/aw9523b/: aw9523b_bsp.c
    ../../bsp/lsm6dsdtr/: lsm6dsdtr_bsp.c
    ../../bsp/ppm/: ppm_bsp.c
    ../../bsp/gc9307c/: gc9307c_bsp.c
    ../../bsp/protocol/: protocol_bsp.c
    ../../bsp/crc/: crc_bsp.c
    ../../bsp/lvgl/: lvgl_bsp.c
    ../../bsp/data/: data_bsp.c
    ../../bsp/wdg/: wdg_bsp.c
  group msp
    ../msp_hal/: msp.c
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c fmc.c i2c.c iwdg.c memorymap.c quadspi.c rtc.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group lvgl/src/core
    ../../app/factory/ui/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../app/factory/ui/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../app/factory/ui/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../app/factory/ui/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/extra
    ../../app/factory/ui/lvgl/lvgl/src/extra/: lv_extra.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_zh_keyboard.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/textprogress/: lv_textprogress.c
    ../../app/factory/ui/lvgl/lvgl/src/extra/widgets/video/: lv_video.c
  group lvgl/src/font
    ../../app/factory/ui/lvgl/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_dejavu_16_persian_hebrew.c
  group lvgl/src/hal
    ../../app/factory/ui/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../app/factory/ui/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../app/factory/ui/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/port
    ../../bsp/lvgl/port/: lv_port_disp.c lv_port_indev.c
  group lvgl/guider
    ../../app/factory/ui/lvgl/generated/: events_init.c gui_guider.c widgets_init.c setup_scr_home.c setup_scr_lcd_light.c setup_scr_vibration.c setup_scr_lcd_screen.c setup_scr_button.c setup_scr_led.c setup_scr_imu.c setup_scr_battery.c setup_scr_headphone.c setup_scr_speaker.c setup_scr_charge_typec.c setup_scr_charge_base.c setup_scr_version.c setup_scr_aging.c setup_scr_rf_update.c setup_scr_interface.c setup_scr_rf_pair.c setup_scr_rf_version.c setup_scr_rf_hf.c setup_scr_battery_life.c
    ../../app/factory/ui/lvgl/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_14.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_10.c
    ../../app/factory/ui/lvgl/generated/images/: _backgroup_320x240.c _battery_empty_222x108.c _battery_full_222x108.c _gray_322x130.c _color_322x130.c _color_320x238.c _gray_320x238.c _led_off_320x220.c
